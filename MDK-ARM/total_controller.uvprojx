# Keil uVision project total_controller.uvprojx, settings and files
target total_controller (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: total_controller +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/app;../User/bsp/bsp_uart;../User/os;../User/utils;../User/Internet/W5500;../User/Internet/device;../User/Internet/socket;../User/Internet/spi;../User/bsp/bsp_hmi;../User/HMI_DRIVE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group USER/app
    ../User/app/: app.c uart_spec.c config.h app_udp.c types.h app_pis_proc.c logic_proc.c
  group USER/os
    ../User/os/: et_os.c et_timer.c klist.h readme.md
  group USER/utils
    ../User/utils/: ring_buffer.c uart_parse.c utils.c
  group USER/bsp
    ../User/bsp/bsp_uart/: bsp_uart.c
    ../User/bsp/bsp_hmi/: bsp_hmi.c
  group USER/Internet
    ../User/Internet/device/: device.c
    ../User/Internet/w5500/: w5500.c
    ../User/Internet/socket/: socket.c
    ../User/Internet/spi/: spi2.c
  group USER/dacai
    ../User/HMI_DRIVE/: cmd_queue.c hmi_driver.c hmi_user_uart.c
software components: CMSIS:CORE 5.6.0
